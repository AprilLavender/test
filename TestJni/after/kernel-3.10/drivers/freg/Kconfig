## TestJni/after/kernel-3.10/drivers/freg/Kconfig
```kconfig
config FREG
	tristate "Fake Register Driver"
	default y
	help
	This is the freg driver for android system.
```
